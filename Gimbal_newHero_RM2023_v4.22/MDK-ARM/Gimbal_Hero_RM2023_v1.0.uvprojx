# Keil uVision project Gimbal_Hero_RM2023_v1.0.uvprojx, settings and files
target Gimbal_Hero_RM2023_v1.0 (5060300::V5.06 update 3 (build 300)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Gimbal_Hero_RM2023_v1.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Tasks;../Bsp;../Comm;../Drivers_Peripheral/Drivers_INS;../Drivers_Peripheral/Drivers_Motor;../Drivers_Peripheral/Drivers_others;../supprot;../algorithm;../algorithm/Include;../Referee
  asm include: ..\\Inc;..\Inc;../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Tasks
    ../Tasks/: rabbit_task.c shoot_task.c gimbal_task.c INS_task.c chassis_task.c comm_task.c
  group Bsp
    ../Bsp/: bsp_can.c bsp_rc.c bsp_pwm.c bsp_spi.c bsp_delay.c bsp_usart.c bsp_buzzer.c
  group Drivers/Motors
    ../Drivers_Peripheral/Drivers_Motor/: motor_can.c fric_motor.c dial_motor.c pitch_motor.c yaw_motor.c aim_motor.c
  group Drivers/INS
    ../Drivers_Peripheral/Drivers_INS/: BMI088driver.c ist8310driver.c ist8310driver_middleware.c BMI088Middleware.c
  group Drivers/Others
    ../Drivers_Peripheral/Drivers_others/: servo.c
  group support
    ../supprot/: pid.c vofa.c music.c delay.c Referee.c
    ../algorithm/: AHRS_middleware.c arm_cortexM4lf_math.lib AHRS.lib
  group Comm
    ../Comm/: can_receive.c remote_control.c can_transmit.c Nmanifold_usart_task.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.6.0
